options:
  parameters:
    author: Noctis Solutions
    generate_options: qt_gui
    id: FullARMA1
    output_language: python
    title: FullARMA1
  states: {}

blocks:
- name: bladerf_args
  id: variable
  parameters:
    value: '"bladerf=" + bladerf_selection + ",buffers=" + str(num_buffers) + ",buflen=" + str(buflen) + ",num_xfers=" + str(num_xfers) + ",verbosity="+verbosity'
  states: {}
- name: bladerf_selection
  id: variable
  parameters:
    value: str(instance) if serial == "" else serial
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to IQ recording
      and adds timestamp and the 
      'note' variable to the filename
    value: record_file_path+note+"_"+str(int(gui_rx_frequency))+"Hz_"+str(int(samp_rate))+"sps_"+str(int(rx_gain))+"dB_"+".cfile"
  states: {}
- name: gui_rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 5
    label: Frequency
    start: '0'
    step: 1e6
    stop: 3.8e9
    value: rx_frequency
  states: {}
- name: mode
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: WBFM / NBFM
    pressed: '1'
    released: '0'
    switchOffBackground: blue
    switchOnBackground: red
    type: int
    value: '0'
  states: {state: disabled}
- name: note
  id: variable_qtgui_entry
  parameters:
    gui_hint: 7,0,1,4
    label: REC NOTE (press enter to update)
    type: string
    value: RECORDING_NOTE
  states: {}
- name: rec_button
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 8,0,1,1
    initPressed: 'False'
    label: RECORD
    pressed: '1'
    released: '0'
    switchOnBackground: red
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: r"/mnt/nvme/recordings"
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_mode
  id: variable_qtgui_toggle_switch
  parameters:
    comment: |-
      Adjust the "On value"
      to your desired RF dB level
    gui_hint: 8,4,1,1
    initPressed: 'False'
    label: TX
    pressed: '10'
    released: '0'
    switchOnBackground: red
    type: int
    value: '0'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: 48000*4
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 48000*4
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/nvme/recordings/RECORDING_NOTE_101500000Hz_2000000sps_20dB_.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: mode
    type: complex
  states: {state: disabled}
- name: buflen
  id: parameter
  parameters:
    label: Length of buffers, in samples. Should be a multiple of 1024.
    value: '4096'
  states: {}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: instance
  id: parameter
  parameters:
    label: 0-indexed device instance describing device to use. Ignored if a serial-number is provided.
    type: intx
    value: '0'
  states: {}
- name: num_buffers
  id: parameter
  parameters:
    label: Number of buffers to use
    type: intx
    value: '16'
  states: {}
- name: num_xfers
  id: parameter
  parameters:
    label: Number of maximum in-flight USB transfers. Should be <= (num-buffers / 2).
    type: intx
    value: '8'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf_args
    bb_gain0: '0'
    freq0: 150e6
    gain0: tx_mode
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf_args
    bb_gain0: '20'
    freq0: gui_rx_frequency
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: gui_rx_frequency
    fftsize: '16384'
    gui_hint: 2, 0, 5, 5
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {state: disabled}
- name: rx_frequency
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: 101.5e6
  states: {}
- name: serial
  id: parameter
  parameters:
    label: bladeRF serial number
    value: '""'
  states: {}
- name: verbosity
  id: parameter
  parameters:
    label: 'libbladeRF log verbosity. Options are: verbose, debug, info, warning, error, critical, silent'
    value: '"info"'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']
- [blocks_selector_0, '0', analog_wfm_rcv_0, '0']
- [blocks_selector_0, '1', analog_nbfm_rx_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
